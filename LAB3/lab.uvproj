# Keil uVision project lab.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89x516RD2 SST
  cpu: IRAM(0-0xFF) XRAM(0-0x2FF) IROM(0-0xFFFF) CLOCK(40000000)
  output: lab +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 12864.c ds1302.c I2C.c main3.c 18B20.c 8DigitalTubeDisplay.c
