# Keil uVision project adc.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C2052AD STC
  cpu: IRAM(0-0xFF) IROM(0-0x7FF) CLOCK(45000000)
  output: adc +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: adc.c uart.c
