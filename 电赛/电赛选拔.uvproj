# Keil uVision project 电赛选拔.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC89C51RC Series
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000)
  output: 电赛选拔 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main1.c
    ./LCD1602/: lcd.c
    ./18B20/: 18B20.c
    ./DS1302/: ds1302.c ds1302.h
