# Keil uVision project lab.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC89C51RC Series
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000)
  output: lab +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 12864.c ds1302.c I2C.c main3.c temp.c
