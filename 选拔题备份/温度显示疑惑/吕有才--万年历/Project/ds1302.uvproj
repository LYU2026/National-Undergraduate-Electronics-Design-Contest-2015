# Keil uVision project ds1302.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C51RC STC89C51RC Series
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0xFFF) CLOCK(45000000)
  output: ds1302 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../Source/: ds1302.c main3.c 12864.c lcd.c
    ../Source/18B20/: temp.c
